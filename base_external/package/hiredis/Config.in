## base_external/package/hiredis/Config.in
```kconfig
config BR2_PACKAGE_HIREDIS_PATCH
    bool
    default y
    depends on BR2_PACKAGE_HIREDIS
```
